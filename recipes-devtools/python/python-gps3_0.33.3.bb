inherit pypi setuptools
require python-gps3.inc
