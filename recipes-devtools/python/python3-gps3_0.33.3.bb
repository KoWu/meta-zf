inherit pypi setuptools3
require python-gps3.inc
