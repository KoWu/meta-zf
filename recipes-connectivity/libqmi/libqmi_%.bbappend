FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

DEPENDS += "glib-2.0-native"

